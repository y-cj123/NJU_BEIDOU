# Keil uVision project uip5.uvprojx, settings and files
target Client (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uip5
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: TARGET_CLIENT USE_STDPERIPH_DRIVER
  c include: .\uip;.\hello-world;.\unix;.\lib;.\apps\ES;.\unix;.\delay;.\sys;.\RTE\Device\STM32F103RC;.\sys;..\uip5
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group unix
    ./unix/: main.c clock-arch.c tapdev.c ENC28J60.C SPI.C stm32f10x_it.c usart.c uart.c uart5.c packet.c delay.c BD_1.c GDW.c
    ./sys/: sys.c
    ./: led.c
  group uip
    ./uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group app
    ./apps/ES/: server.c client.c
target Server (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: as above
  output: uip5 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: TARGET_SERVER USE_STDPERIPH_DRIVER
  c include: .\uip;.\hello-world;.\unix;.\lib;.\apps\ES;.\RTE;.\RTE\Device\STM32F103RC;.\sys;.\sim900a
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
